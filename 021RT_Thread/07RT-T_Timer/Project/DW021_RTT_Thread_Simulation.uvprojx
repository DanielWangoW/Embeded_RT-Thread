# Keil uVision project DW021_RTT_Thread_Simulation.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DW021_RTT_Thread_Simulation
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\User;..\Source\User;..\Source\CMSIS\Core\CM3;..\Source\rtthread3.x\include;..\Source\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../User/: main.c rtconfig.h
    ../Source/CMSIS/Core/CM3/: system_stm32f10x.c
    ../Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group rtt/ports
    ../Source/rtthread3.x/libcpu/arm/cortex-m3/: cpuport.c context_rvds.s
  group rtt/source
    ../Source/rtthread3.x/src/: clock.c idle.c irq.c kservice.c object.c thread.c scheduler.c timer.c
  group doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.4.0
